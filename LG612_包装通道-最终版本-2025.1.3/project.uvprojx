# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output LG612-APP.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: rt-thread\components\net\lwip\port;packages\libmodbus-latest\examples;rt-thread\components\libc\posix\ipc;libraries\HAL_Drivers\CMSIS\Include;packages\agile_modbus-latest\inc;rt-thread\components\drivers\include;rt-thread\components\dfs\include;board;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\drivers\include;rt-thread\components\drivers\usb\usbhost\class;rt-thread\components\finsh;libraries\HAL_Drivers\config;rt-thread\components\net\netdev\include;rt-thread\components\drivers\include;rt-thread\components\drivers\usb\usbhost\core;rt-thread\components\libc\posix\io\stdio;libraries\HAL_Drivers;rt-thread\components\net\sal\include;rt-thread\components\dfs\filesystems\elmfat;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;rt-thread\components\drivers\include;rt-thread\components\drivers\usb\usbhost;applications;rt-thread\components\drivers\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\include;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\libc\compilers\common\extension\fcntl\octal;board\CubeMX_Config\Inc;rt-thread\components\drivers\include;rt-thread\components\net\sal\impl;rt-thread\components\drivers\usb\usbhost\include;packages\libmodbus-latest\inc;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\libc\compilers\common\extension;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;board\ports;rt-thread\components\libc\posix\io\poll;packages\tcpserver-latest;rt-thread\components\libc\compilers\common\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;.\rt-thread\components\legacy\dfs;.\libraries\HAL_Drivers\drv_flash;.\rt-thread\components\utilities\rt-link\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    ./applications/: cpu.c rs4852.c mail_box.c ext_gpio.c kick_egg.c servo_debug.c anlysis_cmd.c servo_control.c servo_common.c alarm_control.c udpserver_user.c app_wdt.c
    applications/: main.c pwm.c crc32.c rs4851.c stepper.c app_oled.c drv_74hxx.c recode_dat.c rty_encoder.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: phy_reset.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/HAL_Drivers/: drv_common.c drv_eth.c drv_gpio.c drv_hwtimer.c drv_pwm.c drv_rtc.c drv_soft_i2c.c drv_usart.c drv_usbh.c
    ./libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Filesystem
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group libmodbus
    packages/libmodbus-latest/examples/: modbus_tcp_test.c
    packages/libmodbus-latest/src/: modbus-data.c modbus-tcp.c modbus.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_pccard.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_iwdg.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rt_usbh
    rt-thread/components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
    rt-thread/components/drivers/usb/usbhost/class/: mass.c udisk.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group agile_modbus
    packages/agile_modbus-latest/src/: agile_modbus_rtu.c agile_modbus_tcp.c aglige_modbus_user.c agile_modbus.c
