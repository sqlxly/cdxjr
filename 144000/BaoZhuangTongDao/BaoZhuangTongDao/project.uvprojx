# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;rt-thread\components\libc\posix\io\eventfd;libraries\HAL_Drivers\drivers;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\CanFestival-latest\examples\master402;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;libraries\HAL_Drivers\CMSIS\Include;applications;board;.;rt-thread\include;rt-thread\components\finsh;rt-thread\components\drivers\include;board\CubeMX_Config\Inc;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;libraries\HAL_Drivers\drivers\config;libraries\HAL_Drivers;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;rt-thread\libcpu\arm\cortex-m4;packages\CanFestival-latest\inc;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;.\EtherCAT_Include;.\EtherCAT_User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: master_pthread.c external_dev_pthread.c IOdriver.c IOdriver.h sn74hc165pwr.c sn74hc165pwr.h devConfig.c devConfig.h drv_button.c drv_button.h ecat_data_proc.c ecat_data_proc.h servo_planner.c servo_planner.h
  group CanFestival
    packages/CanFestival-latest/src/: emcy.c pdo.c objacces.c timer_rtthread.c timer.c can_rtthread.c states.c sdo.c nmtSlave.c sync.c lifegrd.c nmtMaster.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    ./rt-thread/components/drivers/misc/: rt_drv_pwm.c pulse_encoder.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ./board/: arm_cortexM4lf_math.lib
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_can.c drv_gpio.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    ./libraries/HAL_Drivers/drivers/: drv_tim.c drv_pulse_encoder.c drv_pwm.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_lptim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c
  group Master402
    packages/CanFestival-latest/examples/master402/: canopen_callback.c motor_control.c master402_od.c master402_canopen.c
  group EtherCAT_Stack
    ./EtherCAT_Stack/: aoeappl.c bootmode.c coeappl.c diag.c ecataoe.c ecatappl.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c ecatsoe.c el9800appl.c el9800hw.c emcy.c eoeappl.c fc1100hw.c foeappl.c mailbox.c objdef.c sdoserv.c
  group EtherCAT_User
    ./EtherCAT_User/: user_interface.c
