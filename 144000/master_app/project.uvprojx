# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __STDC_LIMIT_MACROS,RT_USING_ARMLIBC, STM32H743xx, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND,__RTTHREAD__
  c include: rt-thread\components\drivers\include;rt-thread\components\drivers\spi;libraries\HAL_Drivers\drivers\config;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\eventfd;.;rt-thread\components\drivers\hwcrypto;rt-thread\components\drivers\include;rt-thread\components\net\lwip\lwip-2.1.2\src\include;rt-thread\components\net\lwip\port;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;board\ports;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include\socket\sys_socket;board\CubeMX_Config\Inc;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\drivers\ktime\inc;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;packages\agile_modbus-latest\util;rt-thread\components\drivers\include;board;packages\at24cxx-latest;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;rt-thread\components\net\sal\include;rt-thread\include;packages\CanFestival-latest\inc;rt-thread\components\libc\posix\pthreads;rt-thread\components\net\sal\include\socket;rt-thread\components\drivers\include;packages\agile_modbus-latest\inc;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\net\sal\impl;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\drivers\ktime;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;rt-thread\components\libc\posix\delay;packages\CanFestival-latest\examples\master402;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers;libraries\HAL_Drivers;rt-thread\components\finsh;.\applications;.\applications\modbus_tcp;.\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Source\Templates\arm\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group agile_modbus
    packages/agile_modbus-latest/src/: agile_modbus_tcp.c agile_modbus_rtu.c agile_modbus.c
    packages/agile_modbus-latest/util/: agile_modbus_slave_util.c
  group Applications
    applications/: main.c
    ./applications/: dev_config.c servo_planner.c user_spi_slaver.c user_encoder.c user_outputIO.c user_inputIO.c user_button.c user_kinco.c user_pid.c user_pid.h user_alarm.c user_FSmachine.c user_FSmachine.h production_param.c production_param.h gatherEggsInfoThread.c ethercat_master_thread.c work_process_thread.c sort_process_thread.c sort_process_thread.h user_sorter.c user_sorter.h user_record.c user_record.h discard_channel.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CanFestival
    packages/CanFestival-latest/src/: emcy.c pdo.c objacces.c timer_rtthread.c timer.c can_rtthread.c states.c sdo.c nmtSlave.c sync.c lifegrd.c nmtMaster.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwcrypto/: hw_crc.c hwcrypto.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pulse_encoder.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    ./libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: arm_cortexM7lfdp_math.lib
    board/: board.c drv_mpu.c
    board/ports/: drv_qspi_flash.c
    libraries/HAL_Drivers/drivers/: drv_crypto.c drv_eth.c drv_gpio.c drv_pulse_encoder.c drv_qspi.c drv_rtc.c drv_soft_i2c.c drv_spi.c drv_tim.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    ./libraries/HAL_Drivers/drivers/: drv_fdcan.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group ktime
    rt-thread/components/drivers/ktime/src/: cputimer.c hrtimer.c boottime.c
  group libcpu
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_tim.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_lptim.c stm32h7xx_hal_eth.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group Master402
    packages/CanFestival-latest/examples/master402/: canopen_callback.c master402_od.c motor_control.c master402_canopen.c
  group POSIX
    rt-thread/components/libc/posix/delay/: delay.c
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
    rt-thread/components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group modbus_tcp
    ./applications/modbus_tcp/: bits.c drv_tcp_common.c input_bits.c input_registers.c mdbus_tcp_master.c mdbus_tcp_slaver.c registers.c dirtyAndColorEggsQueue.c dirtyAndColorEggsQueue.h weighAndCrackQueue.c weighAndCrackQueue.h repostCacheQueue.c repostCacheQueue.h mainOrbitCacheQueue.c mainOrbitCacheQueue.h
  group readme
    ./readme/: readme.txt
