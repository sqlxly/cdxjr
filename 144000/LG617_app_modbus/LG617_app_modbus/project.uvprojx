# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RT_USING_ARM_LIBC, USE_HAL_DRIVER, __RTTHREAD__, STM32H743xx, ARM_MATH_CM7, __CC_ARM, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __CLK_TCK=RT_TICK_PER_SECOND
  c include: packages\agile_button-v1.1.1\inc;packages\agile_modbus-v1.1.2\inc;packages\agile_modbus-v1.1.2\util;packages\at24cxx-latest;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;packages\cpu_usage-latest;.;rt-thread\components\drivers\hwcrypto;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;packages\freemodbus-latest\modbus\include;packages\freemodbus-latest\modbus\rtu;packages\freemodbus-latest\modbus\ascii;packages\freemodbus-latest\modbus\tcp;packages\freemodbus-latest\port;.;rt-thread\include;packages\LedBlink-latest;.;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\net\lwip-2.1.2\src;rt-thread\components\net\lwip-2.1.2\src\include;rt-thread\components\net\lwip-2.1.2\src\arch\include;rt-thread\components\net\lwip-2.1.2\src\include\netif;rt-thread\components\drivers\usb\usbhost;rt-thread\components\drivers\usb\usbhost\class;rt-thread\components\drivers\usb\usbhost\core;rt-thread\components\drivers\usb\usbhost\include;rt-thread\components\drivers\include;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\socket\sys_socket;packages\syswatch-latest\inc;packages\tcpserver-latest;.\tools;.\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Source\Templates\arm\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: app_proc.c can_bus_proc.c fileUpdateProc.c kinco.c push_out.c tcp_modbus.c weighing.c tcp_modbus_master.c drv_tcp_common.c system_workflow.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c context_rvds.S cpuport.c
  group cpu_usage
    packages/cpu_usage-latest/: cpu_usage.c cpu_usage_cmd.c
  group DeviceDrivers
    rt-thread/components/drivers/hwcrypto/: hwcrypto.c hw_crc.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: waitqueue.c ringbuffer.c dataqueue.c pipe.c completion.c workqueue.c ringblk_buf.c
    rt-thread/components/drivers/watchdog/: watchdog.c
    ./rt-thread/components/drivers/can/: can.c
    ./rt-thread/components/drivers/misc/: pulse_encoder.c
  group Drivers
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    ./libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: arm_cortexM7lfdp_math.lib
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: drv_mpu.c board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_crypto.c drv_soft_i2c.c drv_wdt.c drv_usart.c drv_common.c
    ./libraries/HAL_Drivers/: drv_eth.c drv_fdcan.c drv_hx71708.c drv_usbh.c drv_pulse_encoder.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: ff.c dfs_elm.c ffunicode.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group FreeModbus
    packages/freemodbus-latest/port/: porttcp.c port.c porttimer.c portevent.c portserial.c user_mb_app.c
    packages/freemodbus-latest/modbus/: mb.c
    packages/freemodbus-latest/modbus/functions/: mbfuncinput.c mbfuncother.c mbfuncholding.c mbutils.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c
    packages/freemodbus-latest/modbus/rtu/: mbcrc.c
    packages/freemodbus-latest/modbus/tcp/: mbtcp.c
  group Kernel
    rt-thread/src/: components.c kservice.c mem.c thread.c clock.c device.c timer.c mempool.c ipc.c idle.c object.c irq.c scheduler.c
  group LedBlink
    packages/LedBlink-latest/: ledblink.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: stdio.c mem_std.c syscalls.c libc.c
    rt-thread/components/libc/compilers/common/: time.c unistd.c stdlib.c delay.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pwr.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ./libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_fdcan.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group lwIP
    rt-thread/components/net/lwip-2.1.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c if_api.c
    rt-thread/components/net/lwip-2.1.2/src/core/: ip.c netif.c sys.c altcp_alloc.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c altcp.c tcp_in.c dns.c timeouts.c udp.c altcp_tcp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip-2.1.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip-2.1.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.1.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.1.2/src/apps/ping/: ping.c
  group rt_usbh
    rt-thread/components/drivers/usb/usbhost/class/: mass.c udisk.c
    rt-thread/components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
  group syswatch
    packages/syswatch-latest/src/: syswatch.c
  group tcpserver
    packages/tcpserver-latest/: tcpserver.c
  group tools
    ./tools/: common.c filter.c
  group agile_modbus
    ./packages/agile_modbus-v1.1.2/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
    ./packages/agile_modbus-v1.1.2/util/: agile_modbus_slave_util.c
